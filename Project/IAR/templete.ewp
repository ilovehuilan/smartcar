# IAR project templete.ewp, settings and files
configuration mk60d10 (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: MK60D10
  ICCARM.CCIncludePath2: ..\..\..\..\Libraries\drivers\K\inc; ..\..\..\..\Libraries\startup\CoreSupport; ..\..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\..\Libraries\startup\DeviceSupport; ..\src; ..\..\..\..\Libraries\utilities\emWin\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: templete.sim
  ILINK.IlinkOutputFile: templete.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration mk64f12 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK64xX512xxx12 Freescale MK64xX512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MK64F12
  ICCARM.CCIncludePath2: E:\github\smartcar\Libraries\drivers\K\inc; E:\github\smartcar\Libraries\devices\inc; E:\github\smartcar\Libraries\startup\CoreSupport; E:\github\smartcar\Libraries\startup\DeviceSupport\IAR-ARM; E:\github\smartcar\Libraries\startup\DeviceSupport; E:\github\smartcar\Project\src; E:\github\smartcar\Libraries\utilities\emWin\Include
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: templete.srec
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Freescale\MK64xX512_12.icf
  group drivers
    ../../Libraries/drivers/K/src/: adc.c can.c cmp.c common.c cpuidy.c crc.c dac.c dma.c enet.c flash.c flexbus.c ftm.c gpio.c i2c.c lptmr.c nfc.c pdb.c pit.c rtc.c sd.c spi.c systick.c tsi.c uart.c vref.c wdog.c
  group startup_mk60d10
    ../../../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_MK60D10.s
    ../../../../Libraries/startup/DeviceSupport/: system_MK60D10.c
  group statup_mk64f12
    ../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_MK64F12.s
    ../../Libraries/startup/DeviceSupport/: system_MK64F12.c
  group user
    ../../Libraries/devices/src/: feature.c picture.c
    ../src/: key_scan.c main.c oled.c speed_control.c steer_control.c VCAN_OV7725_Eagle.c VCAN_SCCB.c
